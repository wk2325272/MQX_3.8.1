# Keil uVision project sectelnet_twrk70f120m.uvproj, settings and files
target sectelnet Int Flash SramData Debug (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: sectelnet_intflash_d +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\..\lib\twrk70f120m.uv4\bsp;..\..\..\..\lib\twrk70f120m.uv4\psp;..\..\..\..\lib\twrk70f120m.uv4;..\..\..\source\include;..\..\..\source\psp\cortex;..\..;..\..\..\..\lib\twrk70f120m.uv4\bsp\Generated_Code;..\..\..\..\lib\twrk70f120m.uv4\rtcs;..\..\..\..\lib\twrk70f120m.uv4\shell
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\..\lib\twrk70f120m.uv4\bsp\intflash_sramdata.scf
  link misc: ..\..\..\..\lib\twrk70f120m.uv4\bsp\bsp_twrk70f120m_d.lib(linker_symbols.o)
..\..\..\..\lib\twrk70f120m.uv4\bsp\bsp_twrk70f120m_d.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
  group MQX Libraries
    ../../../../lib/twrk70f120m.uv4/: twrk70f120m_lib.txt
    ../../../../lib/twrk70f120m.uv4/psp/: psp_twrk70f120m.lib psp_twrk70f120m_d.lib psp_twrk70f120m.lib psp_twrk70f120m_d.lib
    ../../../../lib/twrk70f120m.uv4/bsp/: bsp_twrk70f120m.lib bsp_twrk70f120m_d.lib bsp_twrk70f120m.lib bsp_twrk70f120m_d.lib
  group Source
    ../../../../demo/security_telnet/: telnet_demo.c lw_telnet.h lw_telnet.c Security_private.h Security_Util.c Security_Shell_Commands.h Security_Shell_Commands.c Security_Public.h Security_Network.c Security_IO.c Security.h
  group RTCS Libraries
    ../../../../lib/twrk70f120m.uv4/rtcs/: rtcs_twrk70f120m.lib rtcs_twrk70f120m_d.lib rtcs_twrk70f120m.lib rtcs_twrk70f120m_d.lib
  group Shell Libraries
    ../../../../lib/twrk70f120m.uv4/shell/: shell_twrk70f120m.lib shell_twrk70f120m_d.lib shell_twrk70f120m.lib shell_twrk70f120m_d.lib
target sectelnet Int Flash SramData Release (ARM-ADS)
  device: MK70FX512xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) IROM2(0x10000000-0x1007FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: sectelnet_inflash +hex
  c flags: Optim=1 OneElfS=1
  c include: as above
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\..\lib\twrk70f120m.uv4\bsp\intflash_sramdata.scf
  link misc: ..\..\..\..\lib\twrk70f120m.uv4\bsp\bsp_twrk70f120m.lib(linker_symbols.o)
..\..\..\..\lib\twrk70f120m.uv4\bsp\bsp_twrk70f120m.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
target sectelnet Int Flash DDRData Debug (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: sectelnet_intflash_d +hex
  c flags: Optim=1 OneElfS=1
  c include: as above
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x70000000 size 0x7fffff0
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\..\lib\twrk70f120m.uv4\bsp\intflash_ddrdata.scf
  link misc: as above
target sectelnet Int Flash DDRData Release (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: sectelnet_intflash_d +hex
  c flags: Optim=1 OneElfS=1
  c include: as above
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x70000000 size 0x7fffff0
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\..\lib\twrk70f120m.uv4\bsp\intflash_ddrdata.scf
  link misc: as above
