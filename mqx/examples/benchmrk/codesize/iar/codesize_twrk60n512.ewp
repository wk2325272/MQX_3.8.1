# IAR project codesize_twrk60n512.ewp, settings and files
configuration Max Release (ARM)
  General.OGChipSelectEditMenu: K60Xxxx Freescale K60Xxxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; FLASH_TARGET; CSCFG_MAX=1
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pe186
  ICCARM.CCIncludePath2: ..\..\..\..\..\lib\twrk60n512.iar\bsp; ..\..\..\..\..\lib\twrk60n512.iar\psp; ..\..\..\..\..\lib\twrk60n512.iar\bsp\Generated_Code; ..\..\..\..\..\lib\twrk60n512.iar; ..\..\..\..\source\include; ..\..\..\..\source\psp\cortex; ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\lib\twrk60n512.iar\bsp; ..\..\..\..\..\lib\twrk60n512.iar\psp; ..\..\..\..\..\lib\twrk60n512.iar\bsp\Generated_Code; ..\..\..\..\..\lib\twrk60n512.iar; ..\..\..\..\source\include; ..
  ILINK.IlinkOutputFile: codesize_twrk60n512.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\lib\twrk60n512.iar\bsp\intflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Typical Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FLASH_TARGET; CSCFG_TYPICAL=1
configuration Small Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FLASH_TARGET; CSCFG_SMALL=1
configuration Tiniest Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FLASH_TARGET; CSCFG_TINIEST=1
  group MQX Libraries
    ../../../../../lib/twrk60n512.iar/bsp/: bsp_twrk60n512.a bsp_twrk60n512_d.a
    ../../../../../lib/twrk60n512.iar/psp/: psp_twrk60n512.a psp_twrk60n512_d.a
    ../../../../../lib/twrk60n512.iar/: twrk60n512_lib.txt
  group Source
    ../: main.c main.h
