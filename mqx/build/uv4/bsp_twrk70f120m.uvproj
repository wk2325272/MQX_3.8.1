# Keil uVision project bsp_twrk70f120m.uvproj, settings and files
target bsp_twrk70f120m Debug (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: bsp_twrk70f120m_d (library)
  AfterMake: ..\bat\bsp_twrk70f120m.bat ..\..\..\lib\twrk70f120m.uv4\bsp uv4 debug twrk70f120m
  c flags: Optim=1 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK, _DEBUG
  c include: ..\..\..\${MCUToolsBaseDir}\ProcessorExpert\lib\Kinetis\pdd\inc;..\..\..\${ProjDirPath}\Generated_Code;..\..\..\${ProjDirPath}\Sources;..\..\..\config\common;..\..\..\config\twrk70f120m;..\..\source\include;..\..\source\psp\cortex;..\..\source\bsp\twrk70f120m;..\..\source\io\adc;..\..\source\io\adc\kadc;..\..\source\io\can\flexcan;..\..\source\io\cm;..\..\source\io\debug;..\..\source\io\enet\Phy;..\..\source\io\enet;..\..\source\io\enet\macnet;..\..\source\io\esdhc;..\..\source\io\flashx;..\..\source\io\flashx\freescale;..\..\source\io\gpio;..\..\source\io\gpio\kgpio;..\..\source\io\hmi\TSS\shared;..\..\source\io\hmi;..\..\source\io\i2c;..\..\source\io\i2c\int;..\..\source\io\i2c\polled;..\..\source\io\io_dun;..\..\source\io\io_mem;..\..\source\io\io_null;..\..\source\io\lpm;..\..\source\io\lwgpio;..\..\source\io\nandflash;..\..\source\io\nandflash\nfc;..\..\source\io\pcb;..\..\source\io\pcb\mqxa;..\..\source\io\pccard;..\..\source\io\pcflash;..\..\source\io\pipe;..\..\source\io\rtc;..\..\source\io\sdcard;..\..\source\io\sdcard\sdcard_esdhc;..\..\source\io\sdcard\sdcard_spi;..\..\source\io\serial;..\..\source\io\spi\int;..\..\source\io\spi\polled;..\..\source\io\spi;..\..\source\io\tchres;..\..\source\io\tfs;..\..\source\io\timer;..\..\source\io\usb
  asm misc: --cpreproc --diag_suppress=1609
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk70f120m.uv4\mqx\intflash.scf
  group twrk70f120m User Config
    ../../../config/twrk70f120m/: user_config.h
  group twrk70f120m BSP Files
    ../../../mqx/source/bsp/twrk70f120m/: PE_LDD.h PE_Types.h TSS_SystemSetup.h bsp.h bsp_cm.c bsp_cm.h bsp_prv.h bsp_rev.h init_adc.c init_bsp.c init_cfcard.c init_enet.c init_esdhc.c init_flashx.c init_gpio.c init_hmi.c init_hw.c init_i2c.c init_iodebug.c init_lpm.c init_lpm.h init_nandflash.c init_sci.c init_sdcard.c init_spi.c init_usb.c mqx_init.c mqx_main.c twrk70f120m.h vectors.c
    ../../../mqx/source/bsp/twrk70f120m/uv4/: linker_symbols.s
  group Peripheral IO Drivers:adc
    ../../../mqx/source/io/adc/: adc.c adc.h adc_conf.h adc_prv.h
  group Peripheral IO Drivers:adc:kadc
    ../../../mqx/source/io/adc/kadc/: adc_kadc.c adc_kadc.h adc_kadc_prv.h adc_mk70.c adc_mk70.h adt_kpdb.c
  group Peripheral IO Drivers:flexcan
    ../../../mqx/source/io/can/flexcan/: flexcan_mk70.c kflexcan.c kflexcan.h kflexcan_int.c
  group Generic IO Drivers:cm
    ../../../mqx/source/io/cm/: cm.c cm.h cm_kinetis.h
  group Generic IO Drivers:debug
    ../../../mqx/source/io/debug/: iodebug.c iodebug.h iodebug_asm.s iodebug_prv.h
  group Peripheral IO Drivers:enet:phy
    ../../../mqx/source/io/enet/Phy/: phy_ksz8041.c phy_ksz8041.h
  group Peripheral IO Drivers:enet
    ../../../mqx/source/io/enet/: enaddr.c enclose.c enerr.c enet.h enet_rev.h enetprv.h eninit.c enjoin.c enleave.c enmediactl.c enopen.c enrecv.c ensend.c enstat.c enstop.c enutil.c ethernet.h
  group Peripheral IO Drivers:enet:macnet
    ../../../mqx/source/io/enet/macnet/: macnet_1588.c macnet_1588.h macnet_init.c macnet_join.c macnet_mii.c macnet_prv.h macnet_receive.c macnet_rejoin.c macnet_rev.h macnet_send.c macnet_stop.c macnet_util.c
  group Peripheral IO Drivers:enet:macnet_kinetis
    ../../../mqx/source/io/enet/macnet/: macnet_mk70.c macnet_mk70.h
  group Peripheral IO Drivers:esdhc
    ../../../mqx/source/io/esdhc/: esdhc.c esdhc.h esdhc_mk70.c esdhc_prv.h
  group Peripheral IO Drivers:flashx
    ../../../mqx/source/io/flashx/: flashx.c flashx.h flashxprv.h
  group Peripheral IO Drivers:flashx:freescale
    ../../../mqx/source/io/flashx/freescale/: flash_ftfe.c flash_ftfe.h flash_ftfe_prv.h flash_mk70.c flash_mk70.h
  group Peripheral IO Drivers:gpio
    ../../../mqx/source/io/gpio/: io_gpio.c io_gpio.h io_gpio_prv.h
  group Peripheral IO Drivers:gpio:knxx
    ../../../mqx/source/io/gpio/kgpio/: io_gpio_kgpio.c io_gpio_kgpio.h io_gpio_kgpio_prv.h
  group Peripheral IO Drivers:hmi:TSS
    ../../../mqx/source/io/hmi/TSS/shared/: TSS_API.h TSS_DataTypes.h TSS_GPIO.h TSS_Sensor.c TSS_Sensor.h TSS_SensorCTS.c TSS_SensorCTS.h TSS_SensorGPIO.c TSS_SensorGPIO.h TSS_SensorKBI.c TSS_SensorKBI.h TSS_SensorPTI.c TSS_SensorPTI.h TSS_SensorTIC.c TSS_SensorTIC.h TSS_SensorTSI.c TSS_SensorTSI.h TSS_StatusCodes.h TSS_SystemSetupData.c TSS_SystemSetupVal.h TSS_Timer.h
  group Peripheral IO Drivers:hmi
    ../../../mqx/source/io/hmi/: btnled.c btnled.h derivative.h hmi_client.c hmi_client.h hmi_lwgpio_provider.c hmi_lwgpio_provider.h hmi_tss_provider.c hmi_tss_provider.h hmi_uids.h
  group Peripheral IO Drivers:i2c
    ../../../mqx/source/io/i2c/: i2c.h i2c_ki2c.h i2c_ki2c_prv.h i2c_mk70.c
  group Peripheral IO Drivers:i2c:int
    ../../../mqx/source/io/i2c/int/: i2c_int.c i2c_int_ki2c.c i2c_int_prv.h
  group Peripheral IO Drivers:i2c:polled
    ../../../mqx/source/io/i2c/polled/: i2c_pol.c i2c_pol_ki2c.c i2c_pol_prv.h
  group Generic IO Drivers:io_dun
    ../../../mqx/source/io/io_dun/: io_dun.c io_dun.h
  group Generic IO Drivers:io_mem
    ../../../mqx/source/io/io_mem/: io_mem.c io_mem.h iomemprv.h
  group Generic IO Drivers:io_null
    ../../../mqx/source/io/io_null/: io_null.c io_null.h ionulprv.h
  group Generic IO Drivers:lpm
    ../../../mqx/source/io/lpm/: lpm.c lpm.h lpm_kinetis.h lpm_prv.h lpm_smc.c
  group Peripheral IO Drivers:lwgpio
    ../../../mqx/source/io/lwgpio/: lwgpio.c lwgpio.h
  group Peripheral IO Drivers:lwgpio:kgpio
    ../../../mqx/source/io/lwgpio/: lwgpio_kgpio.c lwgpio_kgpio.h
  group Peripheral IO Drivers:nandflash
    ../../../mqx/source/io/nandflash/nand_devices/: MT29F2G16.c
    ../../../mqx/source/io/nandflash/: nandflash.c nandflash.h nandflashprv.h
    ../../../mqx/source/io/nandflash/nfc/: nfc.c nfc.h nfc_k70f120m.c
  group Generic IO Drivers:pcb
    ../../../mqx/source/io/pcb/: io_pcb.c io_pcb.h io_pcb2.c iop_inst.c iopcbprv.h
    ../../../mqx/source/io/pcb/mqxa/: pcb_mqxa.c pcb_mqxa.h pcbmqxav.h
  group Peripheral IO Drivers:pccard
    ../../../mqx/source/io/pccard/: apccard.h pccardflexbus.c pccardflexbus.h pccardflexbuspr.h
  group Peripheral IO Drivers:pcflash
    ../../../mqx/source/io/pcflash/: apcflash.c apcflshpr.h ata.h pcflash.h
  group Generic IO Drivers:io_pipe
    ../../../mqx/source/io/pipe/: io_pipe.c io_pipe.h pipe_prv.h
  group Peripheral IO Drivers:rtc
    ../../../mqx/source/io/rtc/: krtc.c krtc.h krtc_ext.c krtc_ext.h rtc.h
  group Peripheral IO Drivers:sdcard
    ../../../mqx/source/io/sdcard/: sdcard.c sdcard.h sdcard_prv.h
  group Peripheral IO Drivers:sdcard:sdcard_esdhc
    ../../../mqx/source/io/sdcard/sdcard_esdhc/: sdcard_esdhc.c sdcard_esdhc.h
  group Peripheral IO Drivers:sdcard:sdcard_spi
    ../../../mqx/source/io/sdcard/sdcard_spi/: sdcard_spi.c sdcard_spi.h
  group Peripheral IO Drivers:serial:int
    ../../../mqx/source/io/serial/int/: serl_int.c serl_int_kuart.c
    ../../../mqx/source/io/serial/: serinprv.h
  group Peripheral IO Drivers:serial
    ../../../mqx/source/io/serial/: io_sinit.c serial.h serl_kuart.h serl_mk70.c
  group Peripheral IO Drivers:serial:polled
    ../../../mqx/source/io/serial/polled/: serl_pol.c serl_pol_kuart.c
    ../../../mqx/source/io/serial/: serplprv.h
  group Peripheral IO Drivers:spi:int
    ../../../mqx/source/io/spi/int/: spi_dma_dspi.c spi_int.c spi_int_prv.h
  group Peripheral IO Drivers:spi:polled
    ../../../mqx/source/io/spi/polled/: spi_pol.c spi_pol_dspi.c spi_pol_prv.h
  group Peripheral IO Drivers:spi
    ../../../mqx/source/io/spi/: spi.h spi_dspi.h spi_dspi_prv.h spi_mk70_dspi.c
  group Peripheral IO Drivers:tchres
    ../../../mqx/source/io/tchres/: tchres.c tchres.h tchres_prv.h
  group Generic IO Drivers:tfs
    ../../../mqx/source/io/tfs/: tfs.c tfs.h tfs_prv.h
  group Peripheral IO Drivers:timer
    ../../../mqx/source/io/timer/: timer_lpt.c timer_lpt.h timer_lpt_kinetis.c
  group Peripheral IO Drivers:usb
    ../../../mqx/source/io/usb/: if_dev_ehci.h if_dev_khci.h if_host_ehci.h if_host_khci.h usb_bsp.h usb_install.c usb_mk70f.c usb_mk70f_device.c
target bsp_twrk70f120m Release (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: bsp_twrk70f120m (library)
  AfterMake: ..\bat\bsp_twrk70f120m.bat ..\..\..\lib\twrk70f120m.uv4\bsp uv4 release twrk70f120m
  c flags: Optim=1 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK, NDEBUG
  c include: as above
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk70f120m.uv4\mqx\intflash.scf
