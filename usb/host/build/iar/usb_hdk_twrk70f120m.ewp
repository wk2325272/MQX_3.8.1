# IAR project usb_hdk_twrk70f120m.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: MQX_DISABLE_CONFIG_CHECK=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.PreInclude: ..\..\..\..\mqx\source\psp\cortex\psp_abi.h
  ICCARM.CCIncludePath2: ..\..\..\..\lib\twrk70f120m.iar\bsp\Generated_Code; ..\..\..\..\lib\twrk70f120m.iar\bsp; ..\..\..\..\lib\twrk70f120m.iar\psp; ..\..\..\..\lib\twrk70f120m.iar; ..\..\source\classes\audio; ..\..\source\classes\cdc; ..\..\source\classes\hid; ..\..\source\classes\hub; ..\..\source\classes\msd\mfs; ..\..\source\classes\msd; ..\..\source\classes\phdc; ..\..\source\classes\printer; ..\..\source\host\ehci; ..\..\source\host\khci; ..\..\source\rtos\mqx; ..\..\..\common\include; ..\..\source\include; ..\..\..\..\config\twrk70f120m
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  postbuild: "..\bat\usb_hdk_ehci_khci.bat" "..\..\..\..\lib\twrk70f120m.iar\usb\host\usb_hdk_twrk70f120m_d.a" IAR
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: MQX_DISABLE_CONFIG_CHECK=1; NDEBUG
  ICCARM.CCOptLevel: 3
  postbuild: "..\bat\usb_hdk_ehci_khci.bat" "..\..\..\..\lib\twrk70f120m.iar\usb\host\usb_hdk_twrk70f120m.a" IAR
  ILINK.IlinkOutputFile: libgeneric.out
  group twrk70f120m Config in lib
    ../../../../lib/twrk70f120m.iar/: twrk70f120m_lib.txt
  group USB Class Drivers/audio
    ../../source/classes/audio/: usb_host_audio.c usb_host_audio.h usb_host_audio_intf.c
  group USB Class Drivers/cdc
    ../../source/classes/cdc/: usb_host_cdc.c usb_host_cdc.h usb_host_cdc_intf.c
  group USB Class Drivers/hid
    ../../source/classes/hid/: usb_host_hid.c usb_host_hid.h
  group USB Class Drivers/hub
    ../../source/classes/hub/: usb_host_hub.c usb_host_hub.h usb_host_hub_prv.h usb_host_hub_sm.c usb_host_hub_sm.h
  group USB Class Drivers/msd
    ../../source/classes/msd/: usb_host_msd_bo.c usb_host_msd_bo.h usb_host_msd_queue.c usb_host_msd_ufi.c usb_host_msd_ufi.h
  group USB Class Drivers/msd/mfs
    ../../source/classes/msd/mfs/: usbmfs.c usbmfs.h usbmfspr.h
  group USB Class Drivers/phdc
    ../../source/classes/phdc/: usb_host_phdc.c usb_host_phdc.h
  group USB Class Drivers/printer
    ../../source/classes/printer/: usb_host_printer.c usb_host_printer.h
  group USB Low Level Driver
    ../../source/host/ehci/: ehci.h ehci_bw.c ehci_bw.h ehci_cache.h ehci_cncl.c ehci_cncl.h ehci_intr.c ehci_intr.h ehci_iso.c ehci_iso.h ehci_main.c ehci_main.h ehci_prv.h ehci_shut.c ehci_shut.h ehci_utl.c ehci_utl.h
    ../../source/host/khci/: khci.c khci.h khci_prv.h
  group USB Host/source
    ../../source/host/: host_ch9.c host_close.c host_cnl.c host_common.c host_dev_list.c host_main.c host_rcv.c host_shut.c host_snd.c
  group USB Host/os
    ../../source/rtos/mqx/: mqx_dll.c mqx_dll.h mqx_host.h usb_mqx.c usb_mqx.h
  group USB Host/include
    ../../../common/include/: usb.h usb_debug.h usb_desc.h usb_error.h usb_misc.h usb_misc_prv.h usb_prv.h usb_types.h
    ../../source/include/: host_ch9.h host_close.h host_cnfg.h host_cnl.h host_common.h host_dev_list.h host_main.h host_rcv.h host_shut.h host_snd.h hostapi.h
