# Keil uVision project usb_hdk_twrk60d100m.uvproj, settings and files
target usb_hdk_twrk60d100m Debug (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: usb_hdk_twrk60d100m_d (library)
  AfterMake: ..\bat\usb_hdk_khci.bat ..\..\..\..\lib\twrk60d100m.uv4\usb\host uv4 debug twrk60d100m
  c flags: Optim=1 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK, _DEBUG
  c include: ..\..\..\..\lib\twrk60d100m.uv4\bsp\Generated_Code;..\..\..\..\lib\twrk60d100m.uv4\bsp;..\..\..\..\lib\twrk60d100m.uv4\psp;..\..\..\..\lib\twrk60d100m.uv4;..\..\source\classes\audio;..\..\source\classes\cdc;..\..\source\classes\hid;..\..\source\classes\hub;..\..\source\classes\msd\mfs;..\..\source\classes\msd;..\..\source\classes\phdc;..\..\source\classes\printer;..\..\source\host\khci;..\..\source\rtos\mqx;..\..\..\common\include;..\..\source\include
  asm misc: --cpreproc --diag_suppress=1609
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60d100m.uv4\mqx\intflash.scf
  group twrk60d100m Config in lib
    ../../../../lib/twrk60d100m.uv4/: twrk60d100m_lib.txt
  group USB Class Drivers:audio
    ../../../../usb/host/source/classes/audio/: usb_host_audio.c usb_host_audio.h usb_host_audio_intf.c
  group USB Class Drivers:cdc
    ../../../../usb/host/source/classes/cdc/: usb_host_cdc.c usb_host_cdc.h usb_host_cdc_intf.c
  group USB Class Drivers:hid
    ../../../../usb/host/source/classes/hid/: usb_host_hid.c usb_host_hid.h
  group USB Class Drivers:hub
    ../../../../usb/host/source/classes/hub/: usb_host_hub.c usb_host_hub.h usb_host_hub_prv.h usb_host_hub_sm.c usb_host_hub_sm.h
  group USB Class Drivers:msd:mfs
    ../../../../usb/host/source/classes/msd/mfs/: usbmfs.c usbmfs.h usbmfspr.h
  group USB Class Drivers:msd
    ../../../../usb/host/source/classes/msd/: usb_host_msd_bo.c usb_host_msd_bo.h usb_host_msd_queue.c usb_host_msd_ufi.c usb_host_msd_ufi.h
  group USB Class Drivers:phdc
    ../../../../usb/host/source/classes/phdc/: usb_host_phdc.c usb_host_phdc.h
  group USB Class Drivers:printer
    ../../../../usb/host/source/classes/printer/: usb_host_printer.c usb_host_printer.h
  group USB Host:source
    ../../../../usb/host/source/host/: host_ch9.c host_close.c host_cnl.c host_common.c host_dev_list.c host_main.c host_rcv.c host_shut.c host_snd.c
  group USB Low Level Driver
    ../../../../usb/host/source/host/khci/: khci.c khci.h khci_prv.h
  group USB Host:os
    ../../../../usb/host/source/rtos/mqx/: mqx_dll.c mqx_dll.h mqx_host.h usb_mqx.c usb_mqx.h
  group USB Host:include
    ../../../../usb/common/include/: usb.h usb_debug.h usb_desc.h usb_error.h usb_misc.h usb_misc_prv.h usb_prv.h usb_types.h
    ../../../../usb/host/source/include/: host_ch9.h host_close.h host_cnfg.h host_cnl.h host_common.h host_dev_list.h host_main.h host_rcv.h host_shut.h host_snd.h hostapi.h
target usb_hdk_twrk60d100m Release (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: as above
  output: usb_hdk_twrk60d100m (library)
  AfterMake: ..\bat\usb_hdk_khci.bat ..\..\..\..\lib\twrk60d100m.uv4\usb\host uv4 release twrk60d100m
  c flags: Optim=1 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK, NDEBUG
  c include: as above
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60d100m.uv4\mqx\intflash.scf
