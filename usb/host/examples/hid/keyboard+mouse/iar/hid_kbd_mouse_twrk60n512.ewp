# IAR project hid_kbd_mouse_twrk60n512.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pe186
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\lib\twrk60n512.iar\bsp; ..\..\..\..\..\..\lib\twrk60n512.iar\psp; ..\..\..\..\..\..\lib\twrk60n512.iar\bsp\Generated_Code; ..\..\..\..\..\..\lib\twrk60n512.iar; ..\..\..\..\..\..\lib\twrk60n512.iar\usb\host; ..\..\..\..\..\..\lib\twrk60n512.iar\usb; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: twrk60n512.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk60n512.iar\bsp\intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk60n512.iar\bsp\ram.icf
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk60n512.iar\bsp\ram.icf
  group MQX Libraries
    ../../../../../../lib/twrk60n512.iar/bsp/: bsp_twrk60n512_d.a bsp_twrk60n512.a
    ../../../../../../lib/twrk60n512.iar/psp/: psp_twrk60n512_d.a psp_twrk60n512.a
    ../../../../../../lib/twrk60n512.iar/: twrk60n512_lib.txt
  group USB Host Libraries
    ../../../../../../lib/twrk60n512.iar/usb/host/: usb_hdk_twrk60n512_d.a usb_classes.c usb_hdk_twrk60n512.a
  group Source
    ../: hidkeyboard.c hidkeyboard.h hidmouse.c hidmouse.h main.c usb_classes.h
