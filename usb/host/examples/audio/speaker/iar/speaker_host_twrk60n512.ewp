# IAR project speaker_host_twrk60n512.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pe186
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\lib\twrk60n512.iar\bsp; ..\..\..\..\..\..\lib\twrk60n512.iar\psp; ..\..\..\..\..\..\lib\twrk60n512.iar\bsp\Generated_Code; ..\..\..\..\..\..\lib\twrk60n512.iar; ..\..\..\..\..\..\lib\twrk60n512.iar\mfs; ..\..\..\..\..\..\lib\twrk60n512.iar\usb\host; ..\..\..\..\..\..\lib\twrk60n512.iar\usb; ..\..\..\..\..\..\lib\twrk60n512.iar\shell; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: twrk60n512.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk60n512.iar\bsp\intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk60n512.iar\bsp\ram.icf
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk60n512.iar\bsp\ram.icf
  group MQX Libraries
    ../../../../../../lib/twrk60n512.iar/bsp/: bsp_twrk60n512_d.a bsp_twrk60n512.a
    ../../../../../../lib/twrk60n512.iar/psp/: psp_twrk60n512_d.a psp_twrk60n512.a
    ../../../../../../lib/twrk60n512.iar/: twrk60n512_lib.txt
  group MFS Libraries
    ../../../../../../lib/twrk60n512.iar/mfs/: mfs_twrk60n512_d.a mfs_twrk60n512.a
  group USB Host Libraries
    ../../../../../../lib/twrk60n512.iar/usb/host/: usb_hdk_twrk60n512_d.a usb_classes.c usb_hdk_twrk60n512.a
  group Shell Libraries
    ../../../../../../lib/twrk60n512.iar/shell/: shell_twrk60n512_d.a shell_twrk60n512.a
  group Source
    ../: audio_speaker.c audio_speaker.h audio_timer.c audio_timer.h sh_audio.c sh_audio.h usb_classes.h wav.c wav.h
