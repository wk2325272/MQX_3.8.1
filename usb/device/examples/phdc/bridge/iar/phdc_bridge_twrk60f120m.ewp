# IAR project phdc_bridge_twrk60f120m.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK60FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pe186
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\lib\twrk60f120m.iar\bsp; ..\..\..\..\..\..\lib\twrk60f120m.iar\psp; ..\..\..\..\..\..\lib\twrk60f120m.iar\bsp\Generated_Code; ..\..\..\..\..\..\lib\twrk60f120m.iar; ..\..\..\..\..\..\lib\twrk60f120m.iar\rtcs; ..\..\..\..\..\..\lib\twrk60f120m.iar\usb\device; ..\..\..\..\..\..\lib\twrk60f120m.iar\usb; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: twrk60f120m.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk60f120m.iar\bsp\intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk60f120m.iar\bsp\ram.icf
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk60f120m.iar\bsp\ram.icf
  group MQX Libraries
    ../../../../../../lib/twrk60f120m.iar/bsp/: bsp_twrk60f120m_d.a bsp_twrk60f120m.a
    ../../../../../../lib/twrk60f120m.iar/psp/: psp_twrk60f120m_d.a psp_twrk60f120m.a
    ../../../../../../lib/twrk60f120m.iar/: twrk60f120m_lib.txt
  group RTCS Libraries
    ../../../../../../lib/twrk60f120m.iar/rtcs/: rtcs_twrk60f120m_d.a rtcs_twrk60f120m.a
  group USB Device Libraries
    ../../../../../../lib/twrk60f120m.iar/usb/device/: usb_ddk_twrk60f120m_d.a usb_ddk_twrk60f120m.a
  group Source
    ../: bridge.c bridge.h ieee11073_nom_codes.h ieee11073_phd_types.h phdc_server.c phdc_server.h usb_descriptor.c usb_descriptor.h
