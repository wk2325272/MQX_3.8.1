# Keil uVision project phdc_bridge_twrk60n512.uvproj, settings and files
target phdc_bridge Int Flash Debug (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: phdc_bridge_intflash_d +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\..\..\..\..\lib\twrk60n512.uv4\bsp;..\..\..\..\..\..\..\lib\twrk60n512.uv4\psp;..\..\..\..\..\..\..\lib\twrk60n512.uv4;..\..\..\source\include;..\..\..\source\psp\cortex;..\..;..\..\..\..\..\..\..\lib\twrk60n512.uv4\usb;..\..\..\..\..\..\..\lib\twrk60n512.uv4;..\..\..\..\..\..\..\lib\twrk60n512.uv4\bsp\Generated_Code;..\..\..\..\..\..\..\lib\twrk60n512.uv4\psp;..\..\..\..\..\..\..\lib\twrk60n512.uv4\bsp;..\..\..\..\..\..\..\lib\twrk60n512.uv4\rtcs;..\..\..\..\..\..\..\lib\twrk60n512.uv4\usb\device
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\..\..\..\..\lib\twrk60n512.uv4\bsp\intflash.scf
  link misc: ..\..\..\..\..\..\..\lib\twrk60n512.uv4\bsp\bsp_twrk60n512_d.lib(linker_symbols.o)
..\..\..\..\..\..\..\lib\twrk60n512.uv4\bsp\bsp_twrk60n512_d.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
  group MQX Libraries
    ../../../../../../../lib/twrk60n512.uv4/: twrk60n512_lib.txt
    ../../../../../../../lib/twrk60n512.uv4/psp/: psp_twrk60n512.lib psp_twrk60n512_d.lib
    ../../../../../../../lib/twrk60n512.uv4/bsp/: bsp_twrk60n512.lib bsp_twrk60n512_d.lib
  group Source
    ../../../../../../../usb/device/examples/phdc/bridge/: usb_descriptor.h usb_descriptor.c phdc_server.h phdc_server.c ieee11073_phd_types.h ieee11073_nom_codes.h bridge.h bridge.c
  group RTCS Libraries
    ../../../../../../../lib/twrk60n512.uv4/rtcs/: rtcs_twrk60n512.lib rtcs_twrk60n512_d.lib
  group USB Device Libraries
    ../../../../../../../lib/twrk60n512.uv4/usb/device/: usb_ddk_twrk60n512.lib usb_ddk_twrk60n512_d.lib
target phdc_bridge Int Flash Release (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: as above
  output: phdc_bridge_inflash +hex
  c flags: Optim=1 OneElfS=1
  c include: as above
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\..\..\..\..\lib\twrk60n512.uv4\bsp\intflash.scf
  link misc: ..\..\..\..\..\..\..\lib\twrk60n512.uv4\bsp\bsp_twrk60n512.lib(linker_symbols.o)
..\..\..\..\..\..\..\lib\twrk60n512.uv4\bsp\bsp_twrk60n512.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
