<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\mqx\build\iar\bsp_twrk70f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\mqx\build\iar\psp_twrk70f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\rtcs\build\iar\rtcs_twrk70f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\mfs\build\iar\mfs_twrk70f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\shell\build\iar\shell_twrk70f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\usb\device\build\iar\usb_ddk_twrk70f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\usb\host\build\iar\usb_hdk_twrk70f120m.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>bsp_twrk70f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>bsp_twrk70f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>psp_twrk70f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>psp_twrk70f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>mfs_twrk70f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mfs_twrk70f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>rtcs_twrk70f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>rtcs_twrk70f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>shell_twrk70f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>shell_twrk70f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>usb_ddk_twrk70f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_ddk_twrk70f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>usb_hdk_twrk70f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_hdk_twrk70f120m</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>bsp_twrk70f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>psp_twrk70f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>rtcs_twrk70f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mfs_twrk70f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>shell_twrk70f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_ddk_twrk70f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_hdk_twrk70f120m</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>bsp_twrk70f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>psp_twrk70f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>rtcs_twrk70f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>mfs_twrk70f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>shell_twrk70f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>usb_ddk_twrk70f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>usb_hdk_twrk70f120m</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


