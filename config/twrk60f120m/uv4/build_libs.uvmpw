<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <WorkspaceName>WorkSpace</WorkspaceName>

  <project>
    <PathAndName>..\..\..\mqx\build\uv4\psp_twrk60f120m.uvproj</PathAndName>
    <NodeIsActive>1</NodeIsActive>
  </project>

  <project>
    <PathAndName>..\..\..\mqx\build\uv4\bsp_twrk60f120m.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>..\..\..\mfs\build\uv4\mfs_twrk60f120m.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>..\..\..\rtcs\build\uv4\rtcs_twrk60f120m.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>..\..\..\shell\build\uv4\shell_twrk60f120m.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>..\..\..\usb\device\build\uv4\usb_ddk_twrk60f120m.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>..\..\..\usb\host\build\uv4\usb_hdk_twrk60f120m.uvproj</PathAndName>
  </project>

</ProjectWorkspace>
