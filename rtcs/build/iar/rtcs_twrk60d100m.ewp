# IAR project rtcs_twrk60d100m.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: MQX_DISABLE_CONFIG_CHECK=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.PreInclude: ..\..\..\mqx\source\psp\cortex\psp_abi.h
  ICCARM.CCIncludePath2: ..\..\..\lib\twrk60d100m.iar\bsp\Generated_Code; ..\..\..\lib\twrk60d100m.iar\bsp; ..\..\..\lib\twrk60d100m.iar\mfs; ..\..\..\lib\twrk60d100m.iar\psp; ..\..\..\lib\twrk60d100m.iar; ..\..\..\mfs\source\include; ..\..\..\mqx\source\include; ..\..\source\httpd; ..\..\source\include; ..\..\..\config\twrk60d100m
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\..\lib\twrk60d100m.iar\bsp\Generated_Code; ..\..\..\lib\twrk60d100m.iar\bsp; ..\..\..\lib\twrk60d100m.iar\mfs; ..\..\..\lib\twrk60d100m.iar\psp; ..\..\..\lib\twrk60d100m.iar; ..\..\..\mfs\source\include; ..\..\..\mqx\source\include; ..\..\source\httpd; ..\..\source\include
  postbuild: "..\bat\rtcs.bat" "..\..\..\lib\twrk60d100m.iar\rtcs\rtcs_twrk60d100m_d.a" IAR
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: MQX_DISABLE_CONFIG_CHECK=1; NDEBUG
  ICCARM.CCOptLevel: 3
  postbuild: "..\bat\rtcs.bat" "..\..\..\lib\twrk60d100m.iar\rtcs\rtcs_twrk60d100m.a" IAR
  ILINK.IlinkOutputFile: libgeneric.out
  group twrk60d100m Config in lib
    ../../../lib/twrk60d100m.iar/: twrk60d100m_lib.txt
  group RTCS Source/apps
    ../../source/apps/: binfile.c coff.c dhcpsrv.c echosrv.c eds.c ftpc.c ftpc_cmd.c ftpclnt.c ftpd.c ftpd_cmd.c ftpd_msg.c loadtb.c loadtc.c loadts.c resolver.c rtcsload.c rtcssh.c sntp.c sockio.c srec32.c srecord.c telnet.c telnetio.c telnsrv.c tftp.c tftpacc.c tftpsrv.c tftputil.c
  group RTCS Source/httpd
    ../../source/httpd/: httpd.c httpd.h httpd_cnfg.h httpd_mqx.h httpd_poll.c httpd_prv.h httpd_supp.c httpd_supp.h httpd_task.c httpd_types.h httpd_wrapper.h
  group RTCS Source/if
    ../../source/if/: arpcmd.c dnshosts.c dnsinit.c dnsutil.c ghbname.c ifadd.c ifbootp.c ifdhcp.c ifdns.c ifppp.c ifrem.c ifstat.c iftraps.c iftunnel.c inet.c ipcfg.c iwcfg.c ping.c rtcs.c rtcscmd.c rtcsdela.c rtcsglob.c rtcshost.c rtcsinit.c rtcslog0.c rtcslog1.c rtcsrand.c sdgram.c select.c sockutil.c soigmp.c soip.c solink.c sosel0.c sosel1.c soselall.c soselset.c sosock.c sotcp.c soudp.c sstream.c
  group RTCS Source/ipc_udp
    ../../source/ipc_udp/: ipc_udp.c
  group RTCS Source/media
    ../../source/media/: arp.c arpinit.c ip-e.c ipcp.c ipcpfsm.c proxyarp.c
  group RTCS Source/os
    ../../source/os/mqx25x/: rtcsdate.c rtcsmsec.c rtcsmsg.c rtcspart.c rtcssec.c rtcstask.c
  group RTCS Source/ppp
    ../../source/ppp/: ccp.c chap.c gen16.c genmd5.c hdlcio.c hdlcio2.c lcp.c lcpif.c md5.c md5step.c pap.c pktrx.c pkttx.c ppp.c pppfsm.c pppglob.c ppphdlc.c
  group RTCS Source/rpc
    ../../source/rpc/: authnone.c clnterr.c clntpmap.c clnttcp.c clntudp.c portmap.c svcauth.c svcpmap.c svcreply.c svcrun.c svctcp.c svcudp.c
  group RTCS Source/snmp
    ../../source/snmp/: 1213.c mib.c mqxmib.c snmp.c trap_receivers.c traps.c
  group RTCS Source/tcpip
    ../../source/tcpip/: bootcomm.c bootinit.c bootp.c checksum.c dhcpclnt.c dhcputil.c icmp.c igmp.c igmputil.c ip.c ip_reasm.c ipif_add.c ipif_rem.c iplocal.c ipradix.c iproute.c iptunnel.c iputil.c rip.c route.c rtcspcb.c tcp.c tcp_buf.c tcp_clos.c tcp_rcv.c tcp_send.c tcpip.c ticker.c timer.c udp.c
  group RTCS Source/xdr
    ../../source/xdr/: xdr.c xdrmem.c xdrpmap.c xdrrec.c xdrrpc.c
  group RTCS Include
    ../../source/include/: arp.h arp_prv.h arpif.h asn1.h auth.h bootp.h ccp.h chap.h checksum.h clnt.h dhcp.h dhcp_prv.h dhcpsrv.h dhcpuprv.h dns.h fcs16.h ftp.h ftpc.h ftpd.h ftpd_msg.h icmp.h icmp_prv.h igmp.h ip-e.h ip.h ip_prv.h ipc_udp.h ipc_udp_prv.h ipcfg.h ipcfg_prv.h ipcp.h ipradix.h iptunnel.h iwcfg.h lcp.h md5.h nat.h nat_prv.h nat_session.h natvers.h pap.h pmap.h pmapif.h ppp.h ppp_prv.h pppfsm.h ppphdlc.h rip.h rip_prv.h route.h rpcmsg.h rpctypes.h rtcs.h rtcs25x.h rtcs_in.h rtcs_prv.h rtcscfg.h rtcshdlc.h rtcslog.h rtcspcb.h rtcsrpc.h rtcsrtos.h rtcstime.h rtcsvers.h select.h snmp.h snmpcfg.h socket.h svc.h svcauth.h tcp.h tcp_prv.h tcpip.h telnet.h tftp.h ticker.h udp.h udp_prv.h xdr.h
