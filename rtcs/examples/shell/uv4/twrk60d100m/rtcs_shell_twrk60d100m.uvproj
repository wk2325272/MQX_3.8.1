# Keil uVision project rtcs_shell_twrk60d100m.uvproj, settings and files
target rtcs_shell Int Flash Debug (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: rtcs_shell_intflash_d +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\..\..\lib\twrk60d100m.uv4\bsp;..\..\..\..\..\lib\twrk60d100m.uv4\psp;..\..\..\..\..\lib\twrk60d100m.uv4;..\..\..\source\include;..\..\..\source\psp\cortex;..\..;..\..\..\..\..\lib\twrk60d100m.uv4;..\..\..\..\..\lib\twrk60d100m.uv4\bsp\Generated_Code;..\..\..\..\..\lib\twrk60d100m.uv4\psp;..\..\..\..\..\lib\twrk60d100m.uv4\bsp;..\..\..\..\..\lib\twrk60d100m.uv4\rtcs;..\..\..\..\..\lib\twrk60d100m.uv4\mfs;..\..\..\..\..\lib\twrk60d100m.uv4\shell
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\..\..\lib\twrk60d100m.uv4\bsp\intflash.scf
  link misc: ..\..\..\..\..\lib\twrk60d100m.uv4\bsp\bsp_twrk60d100m_d.lib(linker_symbols.o)
..\..\..\..\..\lib\twrk60d100m.uv4\bsp\bsp_twrk60d100m_d.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
  group MQX Libraries
    ../../../../../lib/twrk60d100m.uv4/: twrk60d100m_lib.txt
    ../../../../../lib/twrk60d100m.uv4/psp/: psp_twrk60d100m.lib psp_twrk60d100m_d.lib
    ../../../../../lib/twrk60d100m.uv4/bsp/: bsp_twrk60d100m.lib bsp_twrk60d100m_d.lib
  group Source
    ../../../../../rtcs/examples/shell/: demo_cmd.c demo.c config.h
  group RTCS Libraries
    ../../../../../lib/twrk60d100m.uv4/rtcs/: rtcs_twrk60d100m.lib rtcs_twrk60d100m_d.lib
  group MFS Libraries
    ../../../../../lib/twrk60d100m.uv4/mfs/: mfs_twrk60d100m.lib mfs_twrk60d100m_d.lib
  group Shell Libraries
    ../../../../../lib/twrk60d100m.uv4/shell/: shell_twrk60d100m.lib shell_twrk60d100m_d.lib
target rtcs_shell Int Flash Release (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: as above
  output: rtcs_shell_inflash +hex
  c flags: Optim=1 OneElfS=1
  c include: as above
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\..\..\lib\twrk60d100m.uv4\bsp\intflash.scf
  link misc: ..\..\..\..\..\lib\twrk60d100m.uv4\bsp\bsp_twrk60d100m.lib(linker_symbols.o)
..\..\..\..\..\lib\twrk60d100m.uv4\bsp\bsp_twrk60d100m.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
