# Keil uVision project ipc_udp_cpu1_twrk60f120m.uvproj, settings and files
target ipc_udp_cpu1 Int Flash Debug (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE
  output: ipc_udp_cpu1_intflash_d +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\..\..\..\lib\twrk60f120m.uv4\bsp;..\..\..\..\..\..\lib\twrk60f120m.uv4\psp;..\..\..\..\..\..\lib\twrk60f120m.uv4;..\..\..\source\include;..\..\..\source\psp\cortex;..\..\..;..\..\..\..\..\..\lib\twrk60f120m.uv4;..\..\..\..\..\..\lib\twrk60f120m.uv4\bsp\Generated_Code;..\..\..\..\..\..\lib\twrk60f120m.uv4\psp;..\..\..\..\..\..\lib\twrk60f120m.uv4\bsp;..\..\..\..\..\..\lib\twrk60f120m.uv4\rtcs
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\..\..\..\lib\twrk60f120m.uv4\bsp\intflash.scf
  link misc: ..\..\..\..\..\..\lib\twrk60f120m.uv4\bsp\bsp_twrk60f120m_d.lib(linker_symbols.o)
..\..\..\..\..\..\lib\twrk60f120m.uv4\bsp\bsp_twrk60f120m_d.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
  group MQX Libraries
    ../../../../../../lib/twrk60f120m.uv4/: twrk60f120m_lib.txt
    ../../../../../../lib/twrk60f120m.uv4/psp/: psp_twrk60f120m.lib psp_twrk60f120m_d.lib
    ../../../../../../lib/twrk60f120m.uv4/bsp/: bsp_twrk60f120m.lib bsp_twrk60f120m_d.lib
  group Source
    ../../../../../../rtcs/examples/ipc_udp/cpu1/: ipc_udp_1.c
    ../../../../../../rtcs/examples/ipc_udp/: ipc_udp_ex.h
  group RTCS Libraries
    ../../../../../../lib/twrk60f120m.uv4/rtcs/: rtcs_twrk60f120m.lib rtcs_twrk60f120m_d.lib
target ipc_udp_cpu1 Int Flash Release (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: ipc_udp_cpu1_inflash +hex
  c flags: Optim=1 OneElfS=1
  c include: as above
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\..\..\..\lib\twrk60f120m.uv4\bsp\intflash.scf
  link misc: ..\..\..\..\..\..\lib\twrk60f120m.uv4\bsp\bsp_twrk60f120m.lib(linker_symbols.o)
..\..\..\..\..\..\lib\twrk60f120m.uv4\bsp\bsp_twrk60f120m.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
